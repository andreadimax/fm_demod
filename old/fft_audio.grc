options:
  parameters:
    author: andrea
    generate_options: qt_gui
    id: a1
    output_language: python
    run: 'False'
    title: AudioFFT
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/andrea/Documenti/FFT/FM_Demodulator/fm_demod/audio.wav
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_wavfile_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
